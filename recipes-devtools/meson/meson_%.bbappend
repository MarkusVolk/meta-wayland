SRC_URI:remove = "           file://0003-native_bindir.patch \"
SRC_URI:remove = "           file://gi-target-dep.patch \"
SRC_URI:remove = "           file://0001-Make-CPU-family-warnings-fatal.patch \"
PV = "0.59.0"
SRC_URI[sha256sum] = "e376c298df64b643dfe01eccb2d7b6f1e02e95aa38c19f19d120d129612ce476"


