DEPENDS:remove = "gtk+"
DEPENDS:append = " gtk+3"

