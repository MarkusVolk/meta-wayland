PV = "1.20.0"
SRC_URI:remove = "file://0001-build-Fix-strndup-detection-on-MinGW.patch"
SRC_URI[sha256sum] = "b8a034154c7059772e0fdbd27dbfcda6c732df29cae56a82274f6ec5d7cd8725"


