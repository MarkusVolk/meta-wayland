SRC_URI:remove = "    file://0001-Fix-build-with-OpenEXR-3.patch \"
PV = "0.4.32"
SRC_URI[sha256sum] = "668e3c6b9faf75fb00512701c36274ab6f22a8ba05ec62dbf187d34b8d298fa1"

