PV = "1.8.5"
SRCREV = "v${PV}"

